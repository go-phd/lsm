## Kconfig
```kconfig
config SECURITY_PHD
	bool "PHD Support"
	depends on SECURITY
	default y
	help
	  This is phd lsm.
```
